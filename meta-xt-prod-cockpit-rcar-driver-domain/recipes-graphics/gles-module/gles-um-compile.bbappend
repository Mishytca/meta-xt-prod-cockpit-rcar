PV = "1.11"
PVRUM_BRANCH = "1.11/5516664_5.1.0"
SRCREV = "4ed61e604d925bfce8ab16645f48425a581496c7"
EXTRA_OEMAKE += "EXCLUDE_FENCE_SYNC_SUPPORT:=1"
