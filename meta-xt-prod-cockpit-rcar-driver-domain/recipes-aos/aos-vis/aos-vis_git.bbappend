GO_IMPORT = "github.com/aosedge/aos_vis"
BRANCH = "develop"
SRCREV = "962bd0f36e17393f42f067dc12e1e2360aa263c0"
